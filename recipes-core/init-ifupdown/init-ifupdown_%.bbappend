FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:ecu1170 = " file://interfaces"
